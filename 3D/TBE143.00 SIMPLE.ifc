Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: TBE143.00 SIMPLE.ifc
Time: 2023-09-08T10:52:12
Author: Projekty i Wdrożenia
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (35)
Name
2 x  | TBE142.00.02 - Description: TBE142.00.02:1; ObjectType: SketchupComponentInstance
 | LBE140.03.01 - Description: LBE140.03.01:1; ObjectType: SketchupComponentInstance
2 x  | LBE140.02.02_uproszczone - Description: LBE140.02.02_uproszczone:1; ObjectType: SketchupComponentInstance
 | LBE140.03.01(Mirror) - Description: LBE140.03.01(Mirror):1; ObjectType: SketchupComponentInstance
 | LBE140.02.02_uproszczone(Mirror) - Description: LBE140.02.02_uproszczone(Mirror):1; ObjectType: SketchupComponentInstance
 | LBE140.02.01 - Description: LBE140.02.01:1; ObjectType: SketchupComponentInstance
 | LBE140.02.01(Mirror) - Description: LBE140.02.01(Mirror):1; ObjectType: SketchupComponentInstance
 | LBE140.02.02_uproszczone(Mirror) (1) - Description: LBE140.02.02_uproszczone(Mirror) (1):1; ObjectType: SketchupComponentInstance
2 x  | LBE140.01.01_uproszczony - Description: LBE140.01.01_uproszczony:1; ObjectType: SketchupComponentInstance
 | LBE140.01.02 - Description: LBE140.01.02:1; ObjectType: SketchupComponentInstance
2 x  | siedzisko.150.D1 - Description: siedzisko.150.D1:1; ObjectType: SketchupComponentInstance
2 x  | siedzisko.150.D2 - Description: siedzisko.150.D2:1; ObjectType: SketchupComponentInstance
 | siedzisko.150.D2(Mirror) - Description: siedzisko.150.D2(Mirror):1; ObjectType: SketchupComponentInstance
 | siedzisko.150.D2(Mirror) (1) - Description: siedzisko.150.D2(Mirror) (1):1; ObjectType: SketchupComponentInstance
 | siedzisko.150.D1(Mirror) - Description: siedzisko.150.D1(Mirror):1; ObjectType: SketchupComponentInstance
 | siedzisko.150.D1(Mirror) (1) - Description: siedzisko.150.D1(Mirror) (1):1; ObjectType: SketchupComponentInstance
 | LBE140.01.02(Mirror) - Description: LBE140.01.02(Mirror):1; ObjectType: SketchupComponentInstance
 | LBE140.01.01_uproszczony(Mirror) - Description: LBE140.01.01_uproszczony(Mirror):1; ObjectType: SketchupComponentInstance
 | LBE140.01.01_uproszczony(Mirror) (1) - Description: LBE140.01.01_uproszczony(Mirror) (1):1; ObjectType: SketchupComponentInstance
2 x  | TBE142.01.01_uproszczony - Description: TBE142.01.01_uproszczony:1; ObjectType: SketchupComponentInstance
 | TBE142.01.02_uproszczony - Description: TBE142.01.02_uproszczony:1; ObjectType: SketchupComponentInstance
2 x  | TBE142.01.03.D - Description: TBE142.01.03.D:1; ObjectType: SketchupComponentInstance
6 x  | TBE142.01.04.D - Description: TBE142.01.04.D:1; ObjectType: SketchupComponentInstance
